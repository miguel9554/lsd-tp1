*********************************************
** Cargar el inversor generador de la señal de clock
.include inversor_clk.inc

*********************************************
**Fuente de alimentacion
v1 1 0 dc 2.5
*********************************************

*********************************************
** Senal de reloj
* Sintaxis: PULSE(V1 V2 DELAY RISE-TIME FALL-TIME DURACION_PULSO PERIODO)
vp_clk 2 0 PULSE 2.5 0 5n 30ps 30ps 20n 40n
* inversor_clk IN OUT VDD VSS
X0 2 3 1 0 inversor_clk
*********************************************

*********************************************
** Exitacion de entrada del circuito
v_in 4 0 PULSE 0 2.5 30n 30ps 30ps 1000n 2000n
*********************************************

*********************************************
** Flip-flop 1
* dff_x3ry1 RST D CLK QP VDD VSS
* NOTA: El reset se encuentra puesto a masa
X1 0 4 3 5 1 0 dff_x3ry1
*********************************************

*********************************************
** Linea RC
* Ctotal = 1.9e-15
* Rtotal = 5.0
* C por unidad = 3.8e-17
* R por unidad = 0.1

R0 (5 6) r=0.1
C0 (6 0) c=3.8e-17

R1 (6 7) r=0.1
C1 (7 0) c=3.8e-17

R2 (7 8) r=0.1
C2 (8 0) c=3.8e-17

R3 (8 9) r=0.1
C3 (9 0) c=3.8e-17

R4 (9 10) r=0.1
C4 (10 0) c=3.8e-17

R5 (10 11) r=0.1
C5 (11 0) c=3.8e-17

R6 (11 12) r=0.1
C6 (12 0) c=3.8e-17

R7 (12 13) r=0.1
C7 (13 0) c=3.8e-17

R8 (13 14) r=0.1
C8 (14 0) c=3.8e-17

R9 (14 15) r=0.1
C9 (15 0) c=3.8e-17

R10 (15 16) r=0.1
C10 (16 0) c=3.8e-17

R11 (16 17) r=0.1
C11 (17 0) c=3.8e-17

R12 (17 18) r=0.1
C12 (18 0) c=3.8e-17

R13 (18 19) r=0.1
C13 (19 0) c=3.8e-17

R14 (19 20) r=0.1
C14 (20 0) c=3.8e-17

R15 (20 21) r=0.1
C15 (21 0) c=3.8e-17

R16 (21 22) r=0.1
C16 (22 0) c=3.8e-17

R17 (22 23) r=0.1
C17 (23 0) c=3.8e-17

R18 (23 24) r=0.1
C18 (24 0) c=3.8e-17

R19 (24 25) r=0.1
C19 (25 0) c=3.8e-17

R20 (25 26) r=0.1
C20 (26 0) c=3.8e-17

R21 (26 27) r=0.1
C21 (27 0) c=3.8e-17

R22 (27 28) r=0.1
C22 (28 0) c=3.8e-17

R23 (28 29) r=0.1
C23 (29 0) c=3.8e-17

R24 (29 30) r=0.1
C24 (30 0) c=3.8e-17

R25 (30 31) r=0.1
C25 (31 0) c=3.8e-17

R26 (31 32) r=0.1
C26 (32 0) c=3.8e-17

R27 (32 33) r=0.1
C27 (33 0) c=3.8e-17

R28 (33 34) r=0.1
C28 (34 0) c=3.8e-17

R29 (34 35) r=0.1
C29 (35 0) c=3.8e-17

R30 (35 36) r=0.1
C30 (36 0) c=3.8e-17

R31 (36 37) r=0.1
C31 (37 0) c=3.8e-17

R32 (37 38) r=0.1
C32 (38 0) c=3.8e-17

R33 (38 39) r=0.1
C33 (39 0) c=3.8e-17

R34 (39 40) r=0.1
C34 (40 0) c=3.8e-17

R35 (40 41) r=0.1
C35 (41 0) c=3.8e-17

R36 (41 42) r=0.1
C36 (42 0) c=3.8e-17

R37 (42 43) r=0.1
C37 (43 0) c=3.8e-17

R38 (43 44) r=0.1
C38 (44 0) c=3.8e-17

R39 (44 45) r=0.1
C39 (45 0) c=3.8e-17

R40 (45 46) r=0.1
C40 (46 0) c=3.8e-17

R41 (46 47) r=0.1
C41 (47 0) c=3.8e-17

R42 (47 48) r=0.1
C42 (48 0) c=3.8e-17

R43 (48 49) r=0.1
C43 (49 0) c=3.8e-17

R44 (49 50) r=0.1
C44 (50 0) c=3.8e-17

R45 (50 51) r=0.1
C45 (51 0) c=3.8e-17

R46 (51 52) r=0.1
C46 (52 0) c=3.8e-17

R47 (52 53) r=0.1
C47 (53 0) c=3.8e-17

R48 (53 54) r=0.1
C48 (54 0) c=3.8e-17

R49 (54 55) r=0.1
C49 (55 0) c=3.8e-17

*********************************************
** Inversor 2
* inv_x1y1 IN OUT VDD VSS
* NOTA: El reset se encuentra puesto a masa
X2 55 56 1 0 inv_x1y1
*********************************************

*********************************************
** Linea RC
* Ctotal = 7.6e-16
* Rtotal = 2.0
* C por unidad = 1.52e-17
* R por unidad = 0.04

R50 (56 57) r=0.04
C50 (57 0) c=1.52e-17

R51 (57 58) r=0.04
C51 (58 0) c=1.52e-17

R52 (58 59) r=0.04
C52 (59 0) c=1.52e-17

R53 (59 60) r=0.04
C53 (60 0) c=1.52e-17

R54 (60 61) r=0.04
C54 (61 0) c=1.52e-17

R55 (61 62) r=0.04
C55 (62 0) c=1.52e-17

R56 (62 63) r=0.04
C56 (63 0) c=1.52e-17

R57 (63 64) r=0.04
C57 (64 0) c=1.52e-17

R58 (64 65) r=0.04
C58 (65 0) c=1.52e-17

R59 (65 66) r=0.04
C59 (66 0) c=1.52e-17

R60 (66 67) r=0.04
C60 (67 0) c=1.52e-17

R61 (67 68) r=0.04
C61 (68 0) c=1.52e-17

R62 (68 69) r=0.04
C62 (69 0) c=1.52e-17

R63 (69 70) r=0.04
C63 (70 0) c=1.52e-17

R64 (70 71) r=0.04
C64 (71 0) c=1.52e-17

R65 (71 72) r=0.04
C65 (72 0) c=1.52e-17

R66 (72 73) r=0.04
C66 (73 0) c=1.52e-17

R67 (73 74) r=0.04
C67 (74 0) c=1.52e-17

R68 (74 75) r=0.04
C68 (75 0) c=1.52e-17

R69 (75 76) r=0.04
C69 (76 0) c=1.52e-17

R70 (76 77) r=0.04
C70 (77 0) c=1.52e-17

R71 (77 78) r=0.04
C71 (78 0) c=1.52e-17

R72 (78 79) r=0.04
C72 (79 0) c=1.52e-17

R73 (79 80) r=0.04
C73 (80 0) c=1.52e-17

R74 (80 81) r=0.04
C74 (81 0) c=1.52e-17

R75 (81 82) r=0.04
C75 (82 0) c=1.52e-17

R76 (82 83) r=0.04
C76 (83 0) c=1.52e-17

R77 (83 84) r=0.04
C77 (84 0) c=1.52e-17

R78 (84 85) r=0.04
C78 (85 0) c=1.52e-17

R79 (85 86) r=0.04
C79 (86 0) c=1.52e-17

R80 (86 87) r=0.04
C80 (87 0) c=1.52e-17

R81 (87 88) r=0.04
C81 (88 0) c=1.52e-17

R82 (88 89) r=0.04
C82 (89 0) c=1.52e-17

R83 (89 90) r=0.04
C83 (90 0) c=1.52e-17

R84 (90 91) r=0.04
C84 (91 0) c=1.52e-17

R85 (91 92) r=0.04
C85 (92 0) c=1.52e-17

R86 (92 93) r=0.04
C86 (93 0) c=1.52e-17

R87 (93 94) r=0.04
C87 (94 0) c=1.52e-17

R88 (94 95) r=0.04
C88 (95 0) c=1.52e-17

R89 (95 96) r=0.04
C89 (96 0) c=1.52e-17

R90 (96 97) r=0.04
C90 (97 0) c=1.52e-17

R91 (97 98) r=0.04
C91 (98 0) c=1.52e-17

R92 (98 99) r=0.04
C92 (99 0) c=1.52e-17

R93 (99 100) r=0.04
C93 (100 0) c=1.52e-17

R94 (100 101) r=0.04
C94 (101 0) c=1.52e-17

R95 (101 102) r=0.04
C95 (102 0) c=1.52e-17

R96 (102 103) r=0.04
C96 (103 0) c=1.52e-17

R97 (103 104) r=0.04
C97 (104 0) c=1.52e-17

R98 (104 105) r=0.04
C98 (105 0) c=1.52e-17

R99 (105 106) r=0.04
C99 (106 0) c=1.52e-17

*********************************************
** Linea RC
* Ctotal = 1.14e-15
* Rtotal = 3.0
* C por unidad = 2.28e-17
* R por unidad = 0.06

R100 (106 107) r=0.06
C100 (107 0) c=2.28e-17

R101 (107 108) r=0.06
C101 (108 0) c=2.28e-17

R102 (108 109) r=0.06
C102 (109 0) c=2.28e-17

R103 (109 110) r=0.06
C103 (110 0) c=2.28e-17

R104 (110 111) r=0.06
C104 (111 0) c=2.28e-17

R105 (111 112) r=0.06
C105 (112 0) c=2.28e-17

R106 (112 113) r=0.06
C106 (113 0) c=2.28e-17

R107 (113 114) r=0.06
C107 (114 0) c=2.28e-17

R108 (114 115) r=0.06
C108 (115 0) c=2.28e-17

R109 (115 116) r=0.06
C109 (116 0) c=2.28e-17

R110 (116 117) r=0.06
C110 (117 0) c=2.28e-17

R111 (117 118) r=0.06
C111 (118 0) c=2.28e-17

R112 (118 119) r=0.06
C112 (119 0) c=2.28e-17

R113 (119 120) r=0.06
C113 (120 0) c=2.28e-17

R114 (120 121) r=0.06
C114 (121 0) c=2.28e-17

R115 (121 122) r=0.06
C115 (122 0) c=2.28e-17

R116 (122 123) r=0.06
C116 (123 0) c=2.28e-17

R117 (123 124) r=0.06
C117 (124 0) c=2.28e-17

R118 (124 125) r=0.06
C118 (125 0) c=2.28e-17

R119 (125 126) r=0.06
C119 (126 0) c=2.28e-17

R120 (126 127) r=0.06
C120 (127 0) c=2.28e-17

R121 (127 128) r=0.06
C121 (128 0) c=2.28e-17

R122 (128 129) r=0.06
C122 (129 0) c=2.28e-17

R123 (129 130) r=0.06
C123 (130 0) c=2.28e-17

R124 (130 131) r=0.06
C124 (131 0) c=2.28e-17

R125 (131 132) r=0.06
C125 (132 0) c=2.28e-17

R126 (132 133) r=0.06
C126 (133 0) c=2.28e-17

R127 (133 134) r=0.06
C127 (134 0) c=2.28e-17

R128 (134 135) r=0.06
C128 (135 0) c=2.28e-17

R129 (135 136) r=0.06
C129 (136 0) c=2.28e-17

R130 (136 137) r=0.06
C130 (137 0) c=2.28e-17

R131 (137 138) r=0.06
C131 (138 0) c=2.28e-17

R132 (138 139) r=0.06
C132 (139 0) c=2.28e-17

R133 (139 140) r=0.06
C133 (140 0) c=2.28e-17

R134 (140 141) r=0.06
C134 (141 0) c=2.28e-17

R135 (141 142) r=0.06
C135 (142 0) c=2.28e-17

R136 (142 143) r=0.06
C136 (143 0) c=2.28e-17

R137 (143 144) r=0.06
C137 (144 0) c=2.28e-17

R138 (144 145) r=0.06
C138 (145 0) c=2.28e-17

R139 (145 146) r=0.06
C139 (146 0) c=2.28e-17

R140 (146 147) r=0.06
C140 (147 0) c=2.28e-17

R141 (147 148) r=0.06
C141 (148 0) c=2.28e-17

R142 (148 149) r=0.06
C142 (149 0) c=2.28e-17

R143 (149 150) r=0.06
C143 (150 0) c=2.28e-17

R144 (150 151) r=0.06
C144 (151 0) c=2.28e-17

R145 (151 152) r=0.06
C145 (152 0) c=2.28e-17

R146 (152 153) r=0.06
C146 (153 0) c=2.28e-17

R147 (153 154) r=0.06
C147 (154 0) c=2.28e-17

R148 (154 155) r=0.06
C148 (155 0) c=2.28e-17

R149 (155 156) r=0.06
C149 (156 0) c=2.28e-17

*********************************************
** Linea RC
* Ctotal = 2.28e-15
* Rtotal = 6.0
* C por unidad = 4.56e-17
* R por unidad = 0.12

R150 (106 157) r=0.12
C150 (157 0) c=4.56e-17

R151 (157 158) r=0.12
C151 (158 0) c=4.56e-17

R152 (158 159) r=0.12
C152 (159 0) c=4.56e-17

R153 (159 160) r=0.12
C153 (160 0) c=4.56e-17

R154 (160 161) r=0.12
C154 (161 0) c=4.56e-17

R155 (161 162) r=0.12
C155 (162 0) c=4.56e-17

R156 (162 163) r=0.12
C156 (163 0) c=4.56e-17

R157 (163 164) r=0.12
C157 (164 0) c=4.56e-17

R158 (164 165) r=0.12
C158 (165 0) c=4.56e-17

R159 (165 166) r=0.12
C159 (166 0) c=4.56e-17

R160 (166 167) r=0.12
C160 (167 0) c=4.56e-17

R161 (167 168) r=0.12
C161 (168 0) c=4.56e-17

R162 (168 169) r=0.12
C162 (169 0) c=4.56e-17

R163 (169 170) r=0.12
C163 (170 0) c=4.56e-17

R164 (170 171) r=0.12
C164 (171 0) c=4.56e-17

R165 (171 172) r=0.12
C165 (172 0) c=4.56e-17

R166 (172 173) r=0.12
C166 (173 0) c=4.56e-17

R167 (173 174) r=0.12
C167 (174 0) c=4.56e-17

R168 (174 175) r=0.12
C168 (175 0) c=4.56e-17

R169 (175 176) r=0.12
C169 (176 0) c=4.56e-17

R170 (176 177) r=0.12
C170 (177 0) c=4.56e-17

R171 (177 178) r=0.12
C171 (178 0) c=4.56e-17

R172 (178 179) r=0.12
C172 (179 0) c=4.56e-17

R173 (179 180) r=0.12
C173 (180 0) c=4.56e-17

R174 (180 181) r=0.12
C174 (181 0) c=4.56e-17

R175 (181 182) r=0.12
C175 (182 0) c=4.56e-17

R176 (182 183) r=0.12
C176 (183 0) c=4.56e-17

R177 (183 184) r=0.12
C177 (184 0) c=4.56e-17

R178 (184 185) r=0.12
C178 (185 0) c=4.56e-17

R179 (185 186) r=0.12
C179 (186 0) c=4.56e-17

R180 (186 187) r=0.12
C180 (187 0) c=4.56e-17

R181 (187 188) r=0.12
C181 (188 0) c=4.56e-17

R182 (188 189) r=0.12
C182 (189 0) c=4.56e-17

R183 (189 190) r=0.12
C183 (190 0) c=4.56e-17

R184 (190 191) r=0.12
C184 (191 0) c=4.56e-17

R185 (191 192) r=0.12
C185 (192 0) c=4.56e-17

R186 (192 193) r=0.12
C186 (193 0) c=4.56e-17

R187 (193 194) r=0.12
C187 (194 0) c=4.56e-17

R188 (194 195) r=0.12
C188 (195 0) c=4.56e-17

R189 (195 196) r=0.12
C189 (196 0) c=4.56e-17

R190 (196 197) r=0.12
C190 (197 0) c=4.56e-17

R191 (197 198) r=0.12
C191 (198 0) c=4.56e-17

R192 (198 199) r=0.12
C192 (199 0) c=4.56e-17

R193 (199 200) r=0.12
C193 (200 0) c=4.56e-17

R194 (200 201) r=0.12
C194 (201 0) c=4.56e-17

R195 (201 202) r=0.12
C195 (202 0) c=4.56e-17

R196 (202 203) r=0.12
C196 (203 0) c=4.56e-17

R197 (203 204) r=0.12
C197 (204 0) c=4.56e-17

R198 (204 205) r=0.12
C198 (205 0) c=4.56e-17

R199 (205 206) r=0.12
C199 (206 0) c=4.56e-17

*********************************************
** Inversor 3
* inv_x1y1 IN OUT VDD VSS
* NOTA: El reset se encuentra puesto a masa
X3 206 207 1 0 inv_x1y1
*********************************************

*********************************************
** Linea RC
* Ctotal = 1.9e-15
* Rtotal = 5.0
* C por unidad = 3.8e-17
* R por unidad = 0.1

R200 (207 208) r=0.1
C200 (208 0) c=3.8e-17

R201 (208 209) r=0.1
C201 (209 0) c=3.8e-17

R202 (209 210) r=0.1
C202 (210 0) c=3.8e-17

R203 (210 211) r=0.1
C203 (211 0) c=3.8e-17

R204 (211 212) r=0.1
C204 (212 0) c=3.8e-17

R205 (212 213) r=0.1
C205 (213 0) c=3.8e-17

R206 (213 214) r=0.1
C206 (214 0) c=3.8e-17

R207 (214 215) r=0.1
C207 (215 0) c=3.8e-17

R208 (215 216) r=0.1
C208 (216 0) c=3.8e-17

R209 (216 217) r=0.1
C209 (217 0) c=3.8e-17

R210 (217 218) r=0.1
C210 (218 0) c=3.8e-17

R211 (218 219) r=0.1
C211 (219 0) c=3.8e-17

R212 (219 220) r=0.1
C212 (220 0) c=3.8e-17

R213 (220 221) r=0.1
C213 (221 0) c=3.8e-17

R214 (221 222) r=0.1
C214 (222 0) c=3.8e-17

R215 (222 223) r=0.1
C215 (223 0) c=3.8e-17

R216 (223 224) r=0.1
C216 (224 0) c=3.8e-17

R217 (224 225) r=0.1
C217 (225 0) c=3.8e-17

R218 (225 226) r=0.1
C218 (226 0) c=3.8e-17

R219 (226 227) r=0.1
C219 (227 0) c=3.8e-17

R220 (227 228) r=0.1
C220 (228 0) c=3.8e-17

R221 (228 229) r=0.1
C221 (229 0) c=3.8e-17

R222 (229 230) r=0.1
C222 (230 0) c=3.8e-17

R223 (230 231) r=0.1
C223 (231 0) c=3.8e-17

R224 (231 232) r=0.1
C224 (232 0) c=3.8e-17

R225 (232 233) r=0.1
C225 (233 0) c=3.8e-17

R226 (233 234) r=0.1
C226 (234 0) c=3.8e-17

R227 (234 235) r=0.1
C227 (235 0) c=3.8e-17

R228 (235 236) r=0.1
C228 (236 0) c=3.8e-17

R229 (236 237) r=0.1
C229 (237 0) c=3.8e-17

R230 (237 238) r=0.1
C230 (238 0) c=3.8e-17

R231 (238 239) r=0.1
C231 (239 0) c=3.8e-17

R232 (239 240) r=0.1
C232 (240 0) c=3.8e-17

R233 (240 241) r=0.1
C233 (241 0) c=3.8e-17

R234 (241 242) r=0.1
C234 (242 0) c=3.8e-17

R235 (242 243) r=0.1
C235 (243 0) c=3.8e-17

R236 (243 244) r=0.1
C236 (244 0) c=3.8e-17

R237 (244 245) r=0.1
C237 (245 0) c=3.8e-17

R238 (245 246) r=0.1
C238 (246 0) c=3.8e-17

R239 (246 247) r=0.1
C239 (247 0) c=3.8e-17

R240 (247 248) r=0.1
C240 (248 0) c=3.8e-17

R241 (248 249) r=0.1
C241 (249 0) c=3.8e-17

R242 (249 250) r=0.1
C242 (250 0) c=3.8e-17

R243 (250 251) r=0.1
C243 (251 0) c=3.8e-17

R244 (251 252) r=0.1
C244 (252 0) c=3.8e-17

R245 (252 253) r=0.1
C245 (253 0) c=3.8e-17

R246 (253 254) r=0.1
C246 (254 0) c=3.8e-17

R247 (254 255) r=0.1
C247 (255 0) c=3.8e-17

R248 (255 256) r=0.1
C248 (256 0) c=3.8e-17

R249 (256 257) r=0.1
C249 (257 0) c=3.8e-17

*********************************************
** Flip-flop 4
* dff_x3ry1 RST D CLK QP VDD VSS
* NOTA: El reset se encuentra puesto a masa
X4 0 257 3 258 1 0 dff_x3ry1
*********************************************

*********************************************
** Inversor 5
* inv_x1y1 IN OUT VDD VSS
* NOTA: El reset se encuentra puesto a masa
X5 106 259 1 0 inv_x1y1
*********************************************

*********************************************
** Linea RC
* Ctotal = 1.14e-15
* Rtotal = 3.0
* C por unidad = 2.28e-17
* R por unidad = 0.06

R250 (259 260) r=0.06
C250 (260 0) c=2.28e-17

R251 (260 261) r=0.06
C251 (261 0) c=2.28e-17

R252 (261 262) r=0.06
C252 (262 0) c=2.28e-17

R253 (262 263) r=0.06
C253 (263 0) c=2.28e-17

R254 (263 264) r=0.06
C254 (264 0) c=2.28e-17

R255 (264 265) r=0.06
C255 (265 0) c=2.28e-17

R256 (265 266) r=0.06
C256 (266 0) c=2.28e-17

R257 (266 267) r=0.06
C257 (267 0) c=2.28e-17

R258 (267 268) r=0.06
C258 (268 0) c=2.28e-17

R259 (268 269) r=0.06
C259 (269 0) c=2.28e-17

R260 (269 270) r=0.06
C260 (270 0) c=2.28e-17

R261 (270 271) r=0.06
C261 (271 0) c=2.28e-17

R262 (271 272) r=0.06
C262 (272 0) c=2.28e-17

R263 (272 273) r=0.06
C263 (273 0) c=2.28e-17

R264 (273 274) r=0.06
C264 (274 0) c=2.28e-17

R265 (274 275) r=0.06
C265 (275 0) c=2.28e-17

R266 (275 276) r=0.06
C266 (276 0) c=2.28e-17

R267 (276 277) r=0.06
C267 (277 0) c=2.28e-17

R268 (277 278) r=0.06
C268 (278 0) c=2.28e-17

R269 (278 279) r=0.06
C269 (279 0) c=2.28e-17

R270 (279 280) r=0.06
C270 (280 0) c=2.28e-17

R271 (280 281) r=0.06
C271 (281 0) c=2.28e-17

R272 (281 282) r=0.06
C272 (282 0) c=2.28e-17

R273 (282 283) r=0.06
C273 (283 0) c=2.28e-17

R274 (283 284) r=0.06
C274 (284 0) c=2.28e-17

R275 (284 285) r=0.06
C275 (285 0) c=2.28e-17

R276 (285 286) r=0.06
C276 (286 0) c=2.28e-17

R277 (286 287) r=0.06
C277 (287 0) c=2.28e-17

R278 (287 288) r=0.06
C278 (288 0) c=2.28e-17

R279 (288 289) r=0.06
C279 (289 0) c=2.28e-17

R280 (289 290) r=0.06
C280 (290 0) c=2.28e-17

R281 (290 291) r=0.06
C281 (291 0) c=2.28e-17

R282 (291 292) r=0.06
C282 (292 0) c=2.28e-17

R283 (292 293) r=0.06
C283 (293 0) c=2.28e-17

R284 (293 294) r=0.06
C284 (294 0) c=2.28e-17

R285 (294 295) r=0.06
C285 (295 0) c=2.28e-17

R286 (295 296) r=0.06
C286 (296 0) c=2.28e-17

R287 (296 297) r=0.06
C287 (297 0) c=2.28e-17

R288 (297 298) r=0.06
C288 (298 0) c=2.28e-17

R289 (298 299) r=0.06
C289 (299 0) c=2.28e-17

R290 (299 300) r=0.06
C290 (300 0) c=2.28e-17

R291 (300 301) r=0.06
C291 (301 0) c=2.28e-17

R292 (301 302) r=0.06
C292 (302 0) c=2.28e-17

R293 (302 303) r=0.06
C293 (303 0) c=2.28e-17

R294 (303 304) r=0.06
C294 (304 0) c=2.28e-17

R295 (304 305) r=0.06
C295 (305 0) c=2.28e-17

R296 (305 306) r=0.06
C296 (306 0) c=2.28e-17

R297 (306 307) r=0.06
C297 (307 0) c=2.28e-17

R298 (307 308) r=0.06
C298 (308 0) c=2.28e-17

R299 (308 309) r=0.06
C299 (309 0) c=2.28e-17

*********************************************
** Inversor 6
* inv_x1y1 IN OUT VDD VSS
* NOTA: El reset se encuentra puesto a masa
X6 309 310 1 0 inv_x1y1
*********************************************

*********************************************
** Linea RC
* Ctotal = 3.8e-15
* Rtotal = 10.0
* C por unidad = 7.6e-17
* R por unidad = 0.2

R300 (310 311) r=0.2
C300 (311 0) c=7.6e-17

R301 (311 312) r=0.2
C301 (312 0) c=7.6e-17

R302 (312 313) r=0.2
C302 (313 0) c=7.6e-17

R303 (313 314) r=0.2
C303 (314 0) c=7.6e-17

R304 (314 315) r=0.2
C304 (315 0) c=7.6e-17

R305 (315 316) r=0.2
C305 (316 0) c=7.6e-17

R306 (316 317) r=0.2
C306 (317 0) c=7.6e-17

R307 (317 318) r=0.2
C307 (318 0) c=7.6e-17

R308 (318 319) r=0.2
C308 (319 0) c=7.6e-17

R309 (319 320) r=0.2
C309 (320 0) c=7.6e-17

R310 (320 321) r=0.2
C310 (321 0) c=7.6e-17

R311 (321 322) r=0.2
C311 (322 0) c=7.6e-17

R312 (322 323) r=0.2
C312 (323 0) c=7.6e-17

R313 (323 324) r=0.2
C313 (324 0) c=7.6e-17

R314 (324 325) r=0.2
C314 (325 0) c=7.6e-17

R315 (325 326) r=0.2
C315 (326 0) c=7.6e-17

R316 (326 327) r=0.2
C316 (327 0) c=7.6e-17

R317 (327 328) r=0.2
C317 (328 0) c=7.6e-17

R318 (328 329) r=0.2
C318 (329 0) c=7.6e-17

R319 (329 330) r=0.2
C319 (330 0) c=7.6e-17

R320 (330 331) r=0.2
C320 (331 0) c=7.6e-17

R321 (331 332) r=0.2
C321 (332 0) c=7.6e-17

R322 (332 333) r=0.2
C322 (333 0) c=7.6e-17

R323 (333 334) r=0.2
C323 (334 0) c=7.6e-17

R324 (334 335) r=0.2
C324 (335 0) c=7.6e-17

R325 (335 336) r=0.2
C325 (336 0) c=7.6e-17

R326 (336 337) r=0.2
C326 (337 0) c=7.6e-17

R327 (337 338) r=0.2
C327 (338 0) c=7.6e-17

R328 (338 339) r=0.2
C328 (339 0) c=7.6e-17

R329 (339 340) r=0.2
C329 (340 0) c=7.6e-17

R330 (340 341) r=0.2
C330 (341 0) c=7.6e-17

R331 (341 342) r=0.2
C331 (342 0) c=7.6e-17

R332 (342 343) r=0.2
C332 (343 0) c=7.6e-17

R333 (343 344) r=0.2
C333 (344 0) c=7.6e-17

R334 (344 345) r=0.2
C334 (345 0) c=7.6e-17

R335 (345 346) r=0.2
C335 (346 0) c=7.6e-17

R336 (346 347) r=0.2
C336 (347 0) c=7.6e-17

R337 (347 348) r=0.2
C337 (348 0) c=7.6e-17

R338 (348 349) r=0.2
C338 (349 0) c=7.6e-17

R339 (349 350) r=0.2
C339 (350 0) c=7.6e-17

R340 (350 351) r=0.2
C340 (351 0) c=7.6e-17

R341 (351 352) r=0.2
C341 (352 0) c=7.6e-17

R342 (352 353) r=0.2
C342 (353 0) c=7.6e-17

R343 (353 354) r=0.2
C343 (354 0) c=7.6e-17

R344 (354 355) r=0.2
C344 (355 0) c=7.6e-17

R345 (355 356) r=0.2
C345 (356 0) c=7.6e-17

R346 (356 357) r=0.2
C346 (357 0) c=7.6e-17

R347 (357 358) r=0.2
C347 (358 0) c=7.6e-17

R348 (358 359) r=0.2
C348 (359 0) c=7.6e-17

R349 (359 360) r=0.2
C349 (360 0) c=7.6e-17

*********************************************
** Flip-flop 7
* dff_x3ry1 RST D CLK QP VDD VSS
* NOTA: El reset se encuentra puesto a masa
X7 0 360 3 361 1 0 dff_x3ry1
*********************************************

.end
